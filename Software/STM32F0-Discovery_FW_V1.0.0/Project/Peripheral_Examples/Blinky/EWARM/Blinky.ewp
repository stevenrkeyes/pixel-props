# IAR project Blinky.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F051x8 ST STM32F051x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F0XX
  ICCARM.CCIncludePath2: ..\; ..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\Libraries\CMSIS\ST\STM32F0xx\Include; ..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\..\..\..\Utilities\STM32F0-Discovery
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Blinky.srec
  ILINK.IlinkOutputFile: Blinky.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
configuration TIM_PWM_Output (ARM, debug)
  as the first configuration, except:
  group EWARM
    ../../../../Libraries/CMSIS/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f0xx.s
  group STM32F0-Discovery
    ../../../../Utilities/STM32F0-Discovery/: stm32f0_discovery.c
  group STM32F0xx_StdPeriph_Driver
    ../../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_tim.c
  group User
    ../: main.c stm32f0xx_it.c system_stm32f0xx.c
